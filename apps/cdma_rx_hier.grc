<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma_rx_hier</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>category</key><value>cdma</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>cdma_rx_hier</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Es_est_probe</value></param>
<param><key>block_id</key><value>blocks_Es_est_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>elgate_probe</value></param>
<param><key>block_id</key><value>blocks_probe_elgate</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resample_rate</value></param>
<param><key>value</key><value>elgate_probe if  abs(elgate_probe) &lt;0.5  else (  -0.5 if  elgate_probe &lt;-0.5  else 0.5   )</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sqrt_es_inv</value></param>
<param><key>value</key><value>1.0 / (Es_est_probe**0.5 + 1e-19 )</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Ki</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Kp</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_1</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_1_0</value></param>
<param><key>stream_id</key><value>unmodulated output_training</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_1_1</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1_0</value></param>
<param><key>stream_id</key><value>acq frequency</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_0</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2</value></param>
<param><key>stream_id</key><value>header_freq_corrected</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2_0</value></param>
<param><key>stream_id</key><value>payload_freq_corrected</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3_0_0_1</value></param>
<param><key>stream_id</key><value>unmodulated output_training</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3_0_0_1_0</value></param>
<param><key>stream_id</key><value>corrected_out_data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acq</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>acq_frequency</value></param>
<param><key>stream_id</key><value>acq frequency</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-10</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_Es_est_probe</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1</value></param>
<param><key>m</key><value>cp.symbols_per_header</value></param>
<param><key>n</key><value>cp.symbols_per_frame</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1_0</value></param>
<param><key>m</key><value>cp.trellis_coded_payload_symbols_per_frame</value></param>
<param><key>n</key><value>cp.symbols_per_frame</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>cp.symbols_per_header</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1.0/(cp.training_percent/100.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_elgate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>cp.bits_per_uncoded_symbol</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>cp.length_tag_name</value></param>
<param><key>packet_len</key><value>cp.crc_coded_payload_bytes_per_frame</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>sensitivity</key><value>2*numpy.pi</value></param>
</block>
<block>
<key>cdma_amp_var_est</key>
<param><key>id</key><value>cdma_amp_var_est_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
</block>
<block>
<key>cdma_flag_gen</key>
<param><key>id</key><value>cdma_flag_gen_1</value></param>
<param><key>acq</key><value>acq</value></param>
<param><key>period</key><value>cp.chips_per_symbol*cp.symbols_per_frame*cp.samples_per_chip</value></param>
</block>
<block>
<key>cdma_freq_timing_estimator</key>
<param><key>id</key><value>cdma_freq_timing_estimator_0_0</value></param>
<param><key>alpha</key><value>100.0/(cp.chips_per_frame*cp.samples_per_chip)</value></param>
<param><key>factor</key><value>10**(acq_threshold_dB/10)*cp.peak_o_var</value></param>
<param><key>freqs</key><value>cp.freqs</value></param>
<param><key>lookahead</key><value>10*cp.samples_per_chip</value></param>
<param><key>seq1</key><value>(0+0j,) if acq==0 else cp.training[cp.training_filter_length-1::-1]</value></param>
<param><key>seq2</key><value>(0+0j,) if acq==0 else cp.pulse_training_t[::-1]</value></param>
</block>
<block>
<key>cdma_packet_headerparser_b2</key>
<param><key>id</key><value>cdma_packet_headerparser_b2_0</value></param>
<param><key>header_formatter</key><value>cp.local_header_obj</value></param>
</block>
<block>
<key>chopper_correlator</key>
<param><key>id</key><value>chopper_correlator_0</value></param>
<param><key>N</key><value>cp.symbols_per_frame</value></param>
<param><key>Nt</key><value>cp.training_filter_length</value></param>
<param><key>Q</key><value>cp.chips_per_symbol*cp.samples_per_chip</value></param>
<param><key>pulse</key><value>cp.pulse_training_t</value></param>
<param><key>pulse_data</key><value>cp.pulse_data_t</value></param>
<param><key>ts</key><value>cp.training</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0</value></param>
<param><key>constellation</key><value>cp.header_mod.base()</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0_0</value></param>
<param><key>constellation</key><value>cp.payload_mod[0].base()</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_1</value></param>
<param><key>lengthtagname</key><value>cp.length_tag_name</value></param>
<param><key>check</key><value>True</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>early_late_pi_hier</key>
<param><key>id</key><value>early_late_pi_hier_0</value></param>
<param><key>Ki</key><value>Ki</value></param>
<param><key>Kp</key><value>Kp</value></param>
<param><key>acq</key><value>acq</value></param>
<param><key>sqrt_es_inv</key><value>sqrt_es_inv</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>1-resample_rate*(1-acq)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import cdma</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>cp.pulse_shape[::-1]/cp.samples_per_chip</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>unmodulated_out_training</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>N0_est</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>decoded_payload</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>Es_est</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>payload_out_data</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>ack_frequency</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>early_late</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>chopper_input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>chopper_input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>corrected_out_data</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_0</value></param>
<param><key>stream_id</key><value>header_freq_corrected</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_1</value></param>
<param><key>stream_id</key><value>payload_freq_corrected</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>zzz_pad_sink_0_1_0_1_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>decoded_header</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<connection><source_block_id>RX_0_2</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0_1</source_block_id><sink_block_id>chopper_correlator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>RX_0_2_0_1_0</source_block_id><sink_block_id>cdma_amp_var_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0_1_1</source_block_id><sink_block_id>early_late_pi_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1</source_block_id><sink_block_id>cdma_freq_timing_estimator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1_0</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>RX_training_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1_0</source_block_id><sink_block_id>RX_training_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1_0</source_block_id><sink_block_id>pad_sink_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_1</source_block_id><sink_block_id>early_late_pi_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_Es_est_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>pad_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_crc32_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>cdma_amp_var_est_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_amp_var_est_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_flag_gen_1</source_block_id><sink_block_id>RX_training_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator_0_0</source_block_id><sink_block_id>cdma_flag_gen_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator_0_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator_0_0</source_block_id><sink_block_id>acq_frequency</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator_0_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_packet_headerparser_b2_0</source_block_id><sink_block_id>zzz_pad_sink_0_1_0_1_0</sink_block_id><source_key>header_data</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>chopper_correlator_0</source_block_id><sink_block_id>RX_training_0_3_0_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_0</source_block_id><sink_block_id>RX_training_0_3_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>cdma_packet_headerparser_b2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_1</source_block_id><sink_block_id>pad_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>early_late_pi_hier_0</source_block_id><sink_block_id>pad_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>early_late_pi_hier_0</source_block_id><sink_block_id>blocks_probe_elgate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>RX_training_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>chopper_correlator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_1</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
