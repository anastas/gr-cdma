<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma_rx_hier</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>category</key><value>cdma</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>cdma_rx_hier</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RRCF_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(1, samples_per_chip, 1.0, alpha_for_RRCF, RRCF_taps_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freqs</value></param>
<param><key>value</key><value>cp.freqs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>peak_o_var</value></param>
<param><key>value</key><value>cp.peak_o_var</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_for_interp</value></param>
<param><key>value</key><value>(1,) + (0,) * (samples_per_chip-1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cp.training_percent</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RRCF_taps_len</value></param>
<param><key>label</key><value>length for RRCF taps</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_1</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_1_0</value></param>
<param><key>stream_id</key><value>unmodulated output_training</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1_0</value></param>
<param><key>stream_id</key><value>acq frequency</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_0</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2</value></param>
<param><key>stream_id</key><value>header_freq_corrected</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2_0</value></param>
<param><key>stream_id</key><value>payload_freq_corrected</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3_0_0_1</value></param>
<param><key>stream_id</key><value>unmodulated output_training</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3_0_0_1_0</value></param>
<param><key>stream_id</key><value>corrected_out_data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acq</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>acq_frequency</value></param>
<param><key>stream_id</key><value>acq frequency</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha_for_RRCF</value></param>
<param><key>label</key><value>alpha for root-raise coise filter</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/uone/Gnuradio/gnuradioworkspace/CDMA/RRCF.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>m</key><value>50</value></param>
<param><key>n</key><value>54</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1</value></param>
<param><key>m</key><value>cp.symbols_per_header</value></param>
<param><key>n</key><value>cp.symbols_per_frame</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1_0</value></param>
<param><key>m</key><value>cp.trellis_coded_payload_symbols_per_frame</value></param>
<param><key>n</key><value>cp.symbols_per_frame</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>cp.symbols_per_header</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1.0/(cp.training_percent/100.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>cp.bits_per_uncoded_symbol</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>cp.length_tag_name</value></param>
<param><key>packet_len</key><value>cp.crc_coded_payload_bytes_per_frame</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>sensitivity</key><value>2*numpy.pi</value></param>
</block>
<block>
<key>cdma_amp_var_est</key>
<param><key>id</key><value>cdma_amp_var_est_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
</block>
<block>
<key>cdma_flag_gen</key>
<param><key>id</key><value>cdma_flag_gen_1</value></param>
<param><key>acq</key><value>acq</value></param>
<param><key>period</key><value>cp.chips_per_symbol*cp.symbols_per_frame*samples_per_chip</value></param>
</block>
<block>
<key>cdma_freq_timing_estimator</key>
<param><key>id</key><value>cdma_freq_timing_estimator_0</value></param>
<param><key>alpha</key><value>100.0/cp.chips_per_frame</value></param>
<param><key>factor</key><value>10**(acq_threshold_dB/10)*peak_o_var</value></param>
<param><key>freqs</key><value>freqs</value></param>
<param><key>seq1</key><value>(0+0j,) if acq==0 else cp.training[zero_len+1:][::-1]</value></param>
<param><key>seq2</key><value>(0+0j,) if acq==0 else numpy.kron(cp.pulse_training[::-1], taps_for_interp[::-1])</value></param>
</block>
<block>
<key>chopper_correlator</key>
<param><key>id</key><value>chopper_correlator_0</value></param>
<param><key>N</key><value>cp.symbols_per_frame</value></param>
<param><key>Q</key><value>cp.chips_per_symbol*samples_per_chip</value></param>
<param><key>pulse</key><value>numpy.kron(cp.pulse_training, taps_for_interp)</value></param>
<param><key>pulse_data</key><value>numpy.kron(cp.pulse_data, taps_for_interp)</value></param>
<param><key>ts</key><value>cp.training</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0</value></param>
<param><key>constellation</key><value>cp.header_mod.base()</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0_0</value></param>
<param><key>constellation</key><value>cp.payload_mod[0].base()</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_1</value></param>
<param><key>lengthtagname</key><value>cp.length_tag_name</value></param>
<param><key>check</key><value>True</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>digital_packet_headerparser_b</key>
<param><key>id</key><value>digital_packet_headerparser_b_0</value></param>
<param><key>header_formatter</key><value>cp.header_formatter.formatter()</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>RRCF_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio.filter import firdes</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import gnuradio.digital as digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>unmodulated_out_training</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>N0_est</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>decoded_payload</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>Es_est</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>payload_out_data</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>ack_frequency</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>alpha_for_RRCF</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>RRCF_taps_len</value></param>
<param><key>samp_rate</key><value>samples_per_chip</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samples_per_chip</value></param>
<param><key>label</key><value>samples per chip</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>chopper_input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>chopper_input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>corrected_out_data</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_0</value></param>
<param><key>stream_id</key><value>header_freq_corrected</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_1</value></param>
<param><key>stream_id</key><value>payload_freq_corrected</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zero_len</value></param>
<param><key>value</key><value>230</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>zzz_pad_sink_0_1_0_1_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>decoded_header</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<connection><source_block_id>RX_0_2</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0_1</source_block_id><sink_block_id>chopper_correlator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>RX_0_2_0_1_0</source_block_id><sink_block_id>cdma_amp_var_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1</source_block_id><sink_block_id>cdma_freq_timing_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1_0</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>pad_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>RX_training_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1_0</source_block_id><sink_block_id>RX_training_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1_0</source_block_id><sink_block_id>pad_sink_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>pad_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_crc32_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>cdma_amp_var_est_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_amp_var_est_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_flag_gen_1</source_block_id><sink_block_id>RX_training_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator_0</source_block_id><sink_block_id>cdma_flag_gen_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator_0</source_block_id><sink_block_id>acq_frequency</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_0</source_block_id><sink_block_id>RX_training_0_3_0_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_0</source_block_id><sink_block_id>RX_training_0_3_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>digital_packet_headerparser_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_1</source_block_id><sink_block_id>pad_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_packet_headerparser_b_0</source_block_id><sink_block_id>zzz_pad_sink_0_1_0_1_0</sink_block_id><source_key>header_data</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>RX_training_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>RX_training_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>chopper_correlator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_1</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
