<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma_rx</value></param>
<param><key>title</key><value>cdma_rx</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>30000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*chips_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>value</key><value>1e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cdma_parameters.training_percent</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_symbol</value></param>
<param><key>value</key><value>cdma_parameters.chips_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_frame</value></param>
<param><key>value</key><value>cdma_parameters.symbols_per_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto</value></param>
<param><key>value</key><value>0 if EsN0dB_est&gt;EsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dBthreshold</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingSNRdB_est</value></param>
<param><key>value</key><value>10*numpy.log10(Esest_training/(N0est+epsilon)+epsilon)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est</value></param>
<param><key>value</key><value>TrainingSNRdB_est-10*numpy.log10(training_percent)+20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy ; numpy.random.seed(666)</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/zhe/Dropbox/Fall2013/GNU/payloads.fifo</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>payload_mod.bits_per_symbol()</value></param>
<param><key>l</key><value>1</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>payload_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>decoded_payloads</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>payload_mod.bits_per_symbol()</value></param>
<param><key>l</key><value>1</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>'BER'</value></param>
<param><key>win_size</key><value>100000</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(0, 0, 0)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>freq_est_acq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>freq_acq_est</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text</value></param>
<param><key>label</key><value>Ack/Tra Status</value></param>
<param><key>value</key><value>'Acquisition' if onoff==1 else 'Tracking'</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>onoff_manual</value></param>
<param><key>label</key><value>Manual Acq/Tra</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['Tracking','Acquisition']</value></param>
<param><key>type</key><value>button</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>manual</value></param>
<param><key>label</key><value>Manual/Auto</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['Auto','Manual']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>EsN0dB_estimated</value></param>
<param><key>label</key><value>EsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>TrainingSNRdB</value></param>
<param><key>label</key><value>TrainingSNRdB_est</value></param>
<param><key>value</key><value>TrainingSNRdB_est</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>label</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-10</value></param>
<param><key>min</key><value>-20</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cdma_parameters</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/cdma.fifo</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1/(training_percent/100.0)**0.5</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_n0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>blocks_probe_freq</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest_training</value></param>
<param><key>value</key><value>1</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>block_id</key><value>blocks_probe_signal_n0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>decoded_payloads</value></param>
</block>
<block>
<key>cdma_rx_hier</key>
<param><key>id</key><value>cdma_rx_hier_0_0</value></param>
<param><key>onoff</key><value>onoff</value></param>
<param><key>acq_threshold_dB</key><value>acq_threshold_dB</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>chips_per_symbol</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>chips_per_symbol</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_probe_freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_2_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_1_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0_0</source_block_id><sink_block_id>blks2_error_rate_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_float_to_char_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blks2_error_rate_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>blocks_char_to_float_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>payload_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>cdma_rx_hier_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0_0</source_block_id><sink_block_id>blocks_probe_signal_n0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>decoded_header</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0_0</source_block_id><sink_block_id>blocks_probe_signal_amp</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
