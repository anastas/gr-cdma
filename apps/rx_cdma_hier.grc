<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_cdma_hier</value></param>
<param><key>title</key><value>CDMA Rx</value></param>
<param><key>description</key><value>Example of a CDMA Transmitter/Receiver</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pn_data</value></param>
<param><key>value</key><value>cdma_parameters.pn_data</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>var</value></param>
<param><key>value</key><value>(1+(training_percent/100.0)*(2*chips_per_symbol-1.0)/chips_per_symbol)*chips_per_frame - (training_percent/100.0)*chips_per_symbol + chips_per_symbol*10**(-EsN0dBest/10) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_symbol</value></param>
<param><key>value</key><value>cdma_parameters.chips_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_formatter</value></param>
<param><key>value</key><value>cdma_parameters.header_formatter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_tag_name</value></param>
<param><key>value</key><value>cdma_parameters.length_tag_name</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_mod</value></param>
<param><key>value</key><value>cdma_parameters.payload_mod</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_mod</value></param>
<param><key>value</key><value>cdma_parameters.header_mod</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_header</value></param>
<param><key>value</key><value>cdma_parameters.symbols_per_header</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_frame</value></param>
<param><key>value</key><value>cdma_parameters.symbols_per_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_frame</value></param>
<param><key>value</key><value>cdma_parameters.chips_per_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cdma_parameters.training_percent</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pn_training</value></param>
<param><key>value</key><value>cdma_parameters.pn_training</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training</value></param>
<param><key>value</key><value>cdma_parameters.training</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>peak_sq</value></param>
<param><key>value</key><value>chips_per_frame**2 * (training_percent/100.0)</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>symbols_per_frame</value></param>
<param><key>n</key><value>symbols_per_frame+1</value></param>
<param><key>offset</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_1</value></param>
<param><key>stream_id</key><value>pll_out</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_0_0_2</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_0_0_3</value></param>
<param><key>stream_id</key><value>pll_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2</value></param>
<param><key>stream_id</key><value>header_freq_corrected</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2_0</value></param>
<param><key>stream_id</key><value>payload_freq_corrected</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>header_out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0</value></param>
<param><key>constellation</key><value>header_mod.base()</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_0_0_1</value></param>
<param><key>stream_id</key><value>header_freq_corrected</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_0_0_0</value></param>
<param><key>stream_id</key><value>payload_freq_corrected</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0_0</value></param>
<param><key>constellation</key><value>payload_mod.base()</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>data_out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>check</key><value>True</value></param>
<param><key>lengthtagname</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>w</key><value>0.01</value></param>
<param><key>max_freq</key><value>0.02</value></param>
<param><key>min_freq</key><value>-0.02</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>symbols_per_header</value></param>
<param><key>n</key><value>symbols_per_frame</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>header_corrected</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>symbols_per_frame-symbols_per_header</value></param>
<param><key>n</key><value>symbols_per_frame</value></param>
<param><key>offset</key><value>symbols_per_header</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0</value></param>
<param><key>label</key><value>payload_corrected</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_1</value></param>
<param><key>label</key><value>pll_ref</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>training</value></param>
<param><key>tags</key><value>""</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>cdma_kronecker_filter</key>
<param><key>id</key><value>cdma_kronecker_filter_0</value></param>
<param><key>sequence1</key><value>training[::-1]</value></param>
<param><key>sequence2</key><value>pn_training[::-1]</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>chips_per_frame-1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>chips_per_symbol</value></param>
<param><key>taps</key><value>pn_training[::-1]</value></param>
</block>
<block>
<key>cdma_vector_insert2</key>
<param><key>id</key><value>cdma_vector_insert2_1</value></param>
<param><key>data</key><value>(chips_per_symbol-1)*(0,)</value></param>
<param><key>periodicity</key><value>chips_per_frame+1</value></param>
<param><key>offset</key><value>chips_per_frame+1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>chips_per_symbol</value></param>
<param><key>taps</key><value>pn_data[::-1]</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2_0_0</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>symbols_per_frame</value></param>
<param><key>n</key><value>symbols_per_frame+1</value></param>
<param><key>offset</key><value>1</value></param>
</block>
<block>
<key>blocks_peak_detector_xb</key>
<param><key>id</key><value>blocks_peak_detector_xb_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>threshold_factor_rise</key><value>peak_factor * (  peak_sq/var   )</value></param>
<param><key>threshold_factor_fall</key><value>peak_factor * (  peak_sq/var   )</value></param>
<param><key>look_ahead</key><value>0</value></param>
<param><key>alpha</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>peak_factor</value></param>
<param><key>label</key><value>peak_factor</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EsN0dBest</value></param>
<param><key>label</key><value>EsN0dBest</value></param>
<param><key>value</key><value>20</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>cdma_chopper</key>
<param><key>id</key><value>cdma_chopper_0</value></param>
<param><key>length</key><value>chips_per_frame</value></param>
</block>
<block>
<key>cdma_vector_insert2</key>
<param><key>id</key><value>cdma_vector_insert2_0</value></param>
<param><key>data</key><value>0,</value></param>
<param><key>periodicity</key><value>chips_per_frame</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cdma_parameters</value></param>
</block>
<connection><source_block_id>blocks_peak_detector_xb_0</source_block_id><sink_block_id>RX_training_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_peak_detector_xb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>RX_training_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>RX_training_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>RX_training_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>analog_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1_0</source_block_id><sink_block_id>RX_training_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>RX_training_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0_0_0_3</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>RX_0_2_0_0_0_2</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0_0_0_1</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0_0</source_block_id><sink_block_id>digital_crc32_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0_0_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1_0</source_block_id><sink_block_id>pad_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>pad_sink_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0</source_block_id><sink_block_id>cdma_kronecker_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_kronecker_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>cdma_chopper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0</source_block_id><sink_block_id>cdma_chopper_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>cdma_chopper_0</source_block_id><sink_block_id>cdma_vector_insert2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_vector_insert2_0</source_block_id><sink_block_id>cdma_vector_insert2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_vector_insert2_1</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_vector_insert2_1</source_block_id><sink_block_id>fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
