<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>cdma_vector_insert2</key>
<param><key>id</key><value>cdma_vector_insert2_0</value></param>
<param><key>data</key><value>0,</value></param>
<param><key>periodicity</key><value>N</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>flag</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>cdma_chopper</key>
<param><key>id</key><value>cdma_chopper_0</value></param>
<param><key>length</key><value>N</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>N-1</value></param>
</block>
<block>
<key>cdma_vector_insert2</key>
<param><key>id</key><value>cdma_vector_insert2_1</value></param>
<param><key>data</key><value>(N-1)*(0,)</value></param>
<param><key>periodicity</key><value>N+1</value></param>
<param><key>offset</key><value>N+1</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>2</value></param>
<param><key>offset</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>label</key><value>N</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>N</value></param>
<param><key>taps</key><value>filtertaps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filtertaps</value></param>
<param><key>label</key><value>filtertaps</value></param>
<param><key>value</key><value>(0+0j,)</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>chopper_correlator</value></param>
<param><key>title</key><value>chopper_correlator</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>cdma_vector_insert2_1</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_vector_insert2_0</source_block_id><sink_block_id>cdma_vector_insert2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_chopper_0</source_block_id><sink_block_id>cdma_vector_insert2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>cdma_chopper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>cdma_chopper_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
