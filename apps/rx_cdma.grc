<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_cdma</value></param>
<param><key>title</key><value>CDMA Rx</value></param>
<param><key>description</key><value>Example of a CDMA Receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cdma_parameters.training_percent</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_address</value></param>
<param><key>value</key><value>"addr=192.168.40.3"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_sec</value></param>
<param><key>value</key><value>cdma_parameters.chips_per_sec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>raw_payload</value></param>
<param><key>value</key><value>map(int,numpy.random.randint(0,256,raw_payload_bytes_per_frame))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>raw_bytes_per_sec</value></param>
<param><key>value</key><value>cdma_parameters.raw_bytes_per_sec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_sec</value></param>
<param><key>value</key><value>cdma_parameters.symbols_per_sec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_symbol</value></param>
<param><key>value</key><value>cdma_parameters.chips_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_formatter</value></param>
<param><key>value</key><value>cdma_parameters.header_formatter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_tag_name</value></param>
<param><key>value</key><value>cdma_parameters.length_tag_name</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>raw_payload_bytes_per_frame</value></param>
<param><key>value</key><value>cdma_parameters.raw_payload_bytes_per_frame</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>EsN0dBest</value></param>
<param><key>label</key><value>EsN0dBest</value></param>
<param><key>value</key><value>40</value></param>
<param><key>min</key><value>-20</value></param>
<param><key>max</key><value>80</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>payload</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>check</key><value>True</value></param>
<param><key>lengthtagname</key><value></value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>header</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['0','1','2','3','4']</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>header</value></param>
<param><key>stream_id</key><value>header</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>header_0</value></param>
<param><key>stream_id</key><value>payload</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>1.0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cdma_parameters as cdma_parameters</value></param>
</block>
<block>
<key>digital_packet_headerparser_b</key>
<param><key>id</key><value>digital_packet_headerparser_b_0</value></param>
<param><key>header_formatter</key><value>header_formatter.formatter()</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>1.0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>usrp_address</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>chips_per_sec</value></param>
<param><key>center_freq0</key><value>1.5e9</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>byte_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>chips_per_sec</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/cdma</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>average power after training mf</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>chips_per_sec</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>10000</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0.001</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.0001</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>training</value></param>
<param><key>samp_rate</key><value>symbols_per_sec</value></param>
<param><key>v_scale</key><value>5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>5</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>notebook,2</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>channel</value></param>
</block>
<block>
<key>rx_cdma_hier</key>
<param><key>id</key><value>rx_cdma_hier_0</value></param>
<param><key>EsN0dBest</key><value>EsN0dBest</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Raw data after resampling</value></param>
<param><key>samp_rate</key><value>chips_per_sec</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>5</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>window.hanning</value></param>
<param><key>notebook</key><value>notebook,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1_0_0_0_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>pll_reference</value></param>
<param><key>samp_rate</key><value>symbols_per_sec</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.5</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>notebook,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>header_freq_corrected</value></param>
<param><key>samp_rate</key><value>symbols_per_sec</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.5</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>notebook,2</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>payload_freq_corrected</value></param>
<param><key>samp_rate</key><value>symbols_per_sec</value></param>
<param><key>v_scale</key><value>0.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.5</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>notebook,3</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>RX_training</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>byte_rate</source_block_id><sink_block_id>RX_training</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_cdma_hier_0</source_block_id><sink_block_id>header_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_cdma_hier_0</source_block_id><sink_block_id>header</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_cdma_hier_0</source_block_id><sink_block_id>wxgui_scopesink2_1_0_0_0_1_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>digital_crc32_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>digital_packet_headerparser_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_packet_headerparser_b_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>header_data</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>wxgui_scopesink2_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_cdma_hier_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_feedforward_agc_cc_0_0</source_block_id><sink_block_id>wxgui_scopesink2_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_cdma_hier_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>byte_rate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>rx_cdma_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
