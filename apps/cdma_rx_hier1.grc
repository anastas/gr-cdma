<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma_rx_hier1</value></param>
<param><key>title</key><value>cdma_rx_hier1</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>cdma</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cp.training_percent</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>peak_o_var</value></param>
<param><key>value</key><value>cp.peak_o_var</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freqs</value></param>
<param><key>value</key><value>cp.freqs</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>label</key><value>ack_frequency</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>acq_frequency</value></param>
<param><key>stream_id</key><value>acq frequency</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>cdma_flag_gen</key>
<param><key>id</key><value>cdma_flag_gen_1</value></param>
<param><key>acq</key><value>acq</value></param>
<param><key>period</key><value>cp.chips_per_symbol*cp.symbols_per_frame</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/anastas/Dropbox/gnuradio_source/gr-cdma/apps/flags1.data</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/anastas/Dropbox/gnuradio_source/gr-cdma/apps/flags.data</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/anastas/Dropbox/gnuradio_source/gr-cdma/apps/freq.data</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/anastas/Dropbox/gnuradio_source/gr-cdma/apps/cor.data</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>chopper_input</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3_0_0_1</value></param>
<param><key>stream_id</key><value>unmodulated output_training</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3_0_0_1_0</value></param>
<param><key>stream_id</key><value>corrected_out_data</value></param>
</block>
<block>
<key>cdma_freq_timing_estimator1</key>
<param><key>id</key><value>cdma_freq_timing_estimator1_0</value></param>
<param><key>seq1</key><value>(0+0j,) if acq==0 else cp.training[::-1]</value></param>
<param><key>seq2</key><value>(0+0j,) if acq==0 else cp.pulse_training[::-1]</value></param>
<param><key>factor</key><value>10**(acq_threshold_dB/10)*peak_o_var</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>freqs</key><value>freqs</value></param>
</block>
<block>
<key>chopper_correlator1</key>
<param><key>id</key><value>chopper_correlator1_0</value></param>
<param><key>Q</key><value>cp.chips_per_symbol</value></param>
<param><key>pulse</key><value>cp.pulse_training</value></param>
<param><key>N</key><value>cp.symbols_per_frame</value></param>
<param><key>ts</key><value>cp.training</value></param>
<param><key>pulse_data</key><value>cp.pulse_data</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acq</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_0</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1_0</value></param>
<param><key>stream_id</key><value>acq frequency</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>sensitivity</key><value>2*numpy.pi</value></param>
<param><key>amplitude</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>chopper_input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_1</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-10</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/anastas/Dropbox/gnuradio_source/gr-cdma/apps/rx.data</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2</value></param>
<param><key>stream_id</key><value>header_freq_corrected</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_2_0</value></param>
<param><key>stream_id</key><value>payload_freq_corrected</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>cp.symbols_per_header</value></param>
<param><key>n</key><value>cp.symbols_per_frame</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>corrected_out_data</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_0</value></param>
<param><key>label</key><value>N0_est</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2.0</value></param>
</block>
<block>
<key>amp_var_est_hier</key>
<param><key>id</key><value>amp_var_est_hier_1</value></param>
<param><key>alpha</key><value>0.001</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_1</value></param>
<param><key>label</key><value>Es_est</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.0/(cp.training_percent/100.0)</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0_1_0</value></param>
<param><key>stream_id</key><value>unmodulated output_training</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_0</value></param>
<param><key>stream_id</key><value>header_freq_corrected</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>est_tcm_type</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>unmodulated_out_training</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>trellis_viterbi_combined_xx</key>
<param><key>id</key><value>trellis_viterbi_combined_xx_0</value></param>
<param><key>type</key><value>c</value></param>
<param><key>out_type</key><value>b</value></param>
<param><key>fsm_args</key><value>trellis.fsm(cp.fsm[est_tcm_type])</value></param>
<param><key>block_size</key><value>cp.trellis_coded_payload_symbols_per_frame</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>final_state</key><value>0</value></param>
<param><key>dim</key><value>1</value></param>
<param><key>table</key><value>[x*cp.rx_scaling_factor[est_tcm_type] for x in cp.payload_mod[est_tcm_type].points()]</value></param>
<param><key>metric_type</key><value>digital.TRELLIS_EUCLIDEAN</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>cp.trellis_coded_payload_symbols_per_frame</value></param>
<param><key>n</key><value>cp.symbols_per_frame</value></param>
<param><key>offset</key><value>cp.symbols_per_header</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>cp.bits_per_uncoded_symbol</value></param>
<param><key>l</key><value>8</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1_0_0_0</value></param>
<param><key>label</key><value>decoded_payload_bytes</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_1_0</value></param>
<param><key>stream_id</key><value>payload_freq_corrected</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0</value></param>
<param><key>constellation</key><value>cp.header_mod.base()</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>zzz_pad_sink_0_1_0_1_0</value></param>
<param><key>label</key><value>decoded_header</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>digital_packet_headerparser_b_default</key>
<param><key>id</key><value>digital_packet_headerparser_b_default_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>header_len</key><value>36</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>digital_packet_headerparser_b2_default</key>
<param><key>id</key><value>digital_packet_headerparser_b2_default_0</value></param>
<param><key>header_len</key><value>cp.bits_per_header</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<connection><source_block_id>cdma_freq_timing_estimator1_0</source_block_id><sink_block_id>acq_frequency</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator1_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator1_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0_1</source_block_id><sink_block_id>chopper_correlator1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>chopper_correlator1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_flag_gen_1</source_block_id><sink_block_id>RX_training_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator1_0</source_block_id><sink_block_id>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator1_0</source_block_id><sink_block_id>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator1_0</source_block_id><sink_block_id>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_freq_timing_estimator1_0</source_block_id><sink_block_id>cdma_flag_gen_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_flag_gen_1</source_block_id><sink_block_id>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator1_0</source_block_id><sink_block_id>RX_training_0_3_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator1_0</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator1_0</source_block_id><sink_block_id>RX_training_0_3_0_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>RX_training_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1_0</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>pad_sink_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1_0</source_block_id><sink_block_id>RX_training_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>RX_training_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>pad_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amp_var_est_hier_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0_1_0</source_block_id><sink_block_id>amp_var_est_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>amp_var_est_hier_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>pad_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_packet_headerparser_b2_default_0</source_block_id><sink_block_id>zzz_pad_sink_0_1_0_1_0</sink_block_id><source_key>header_data</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>digital_packet_headerparser_b2_default_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_viterbi_combined_xx_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_1_0</source_block_id><sink_block_id>trellis_viterbi_combined_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1</source_block_id><sink_block_id>blocks_file_sink_0_2_0_0_0_5_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1</source_block_id><sink_block_id>cdma_freq_timing_estimator1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>digital_packet_headerparser_b_default_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_packet_headerparser_b_default_0</source_block_id><sink_block_id>zzz_pad_sink_0_1_0_1_0</sink_block_id><source_key>out</source_key><sink_key>0</sink_key></connection>
</flow_graph>
