<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma_rx1</value></param>
<param><key>title</key><value>cdma_rx1</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>appr_tcm_type</value></param>
<param><key>value</key><value>2 if (DataEsN0dB_est&lt;=15.0) else (1 if (DataEsN0dB_est&lt;=20.0) else 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>est_tcm_type</value></param>
<param><key>value</key><value>est_tcm_type1 if (est_tcm_type1 &gt;=0 and est_tcm_type1 &lt;=2) else 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>df</value></param>
<param><key>value</key><value>cp.df*samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingEsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est + 10*numpy.log10( training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DataEsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est + 10*numpy.log10( 1.0-training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est</value></param>
<param><key>value</key><value>10*numpy.log10(  cp.epsilon + abs(Esest)/ (abs(N0est)+cp.epsilon)  )   </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cp.training_percent</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*chips_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_symbol</value></param>
<param><key>value</key><value>cp.chips_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_bytes_per_frame</value></param>
<param><key>value</key><value>cp.payload_bytes_per_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_frame</value></param>
<param><key>value</key><value>cp.symbols_per_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto</value></param>
<param><key>value</key><value>0 if DataEsN0dB_est&gt;DataEsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy ; numpy.random.seed(666)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_2</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_2_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_n0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>decoded_payload_bytes</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>msg_debug</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>2.2e9</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/tmp/cdma.fifo</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>cdma_rx_hier1</key>
<param><key>id</key><value>cdma_rx_hier1_1</value></param>
<param><key>acq</key><value>onoff</value></param>
<param><key>acq_threshold_dB</key><value>acq_threshold_dB</value></param>
<param><key>est_tcm_type</key><value>est_tcm_type</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text</value></param>
<param><key>label</key><value>Ack/Tra Status</value></param>
<param><key>value</key><value>'Acquisition' if onoff==1 else 'Tracking'</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>onoff_manual</value></param>
<param><key>label</key><value>Manual Acq/Tra</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['Tracking','Acquisition']</value></param>
<param><key>type</key><value>button</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>manual</value></param>
<param><key>label</key><value>Manual/Auto</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['Auto','Manual']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>label</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-10</value></param>
<param><key>min</key><value>-40</value></param>
<param><key>max</key><value>20</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>DataEsN0dBthreshold</value></param>
<param><key>label</key><value>DataEsN0dBthreshold</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>20</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>dft</value></param>
<param><key>label</key><value>Deltaf (Hz)</value></param>
<param><key>value</key><value>df</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>freq_est_acq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>freq_acq_est</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>fmaxt</value></param>
<param><key>label</key><value>f_max (Hz)</value></param>
<param><key>value</key><value>cp.freqs[-1]*samp_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>TrainingEsN0dB</value></param>
<param><key>label</key><value>TrainingEsN0dB_est</value></param>
<param><key>value</key><value>TrainingEsN0dB_est</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>DataEsN0dB_estimated</value></param>
<param><key>label</key><value>DataEsN0dB_est</value></param>
<param><key>value</key><value>DataEsN0dB_est</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>callback</key><value>set_tcm_type_selector</value></param>
<param><key>variable</key><value>appr_tcm_type</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>blocks_probe_freq</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>delay</key><value>0.0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_n0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>delay</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>delay</key><value>1.0</value></param>
</block>
<block>
<key>variable_message_probe</key>
<param><key>id</key><value>est_tcm_type1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>msg_block_id</key><value>msg_debug</value></param>
<param><key>code_type_tag</key><value>tcm_type</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_probe_freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier1_1</source_block_id><sink_block_id>blocks_probe_signal_n0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier1_1</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier1_1</source_block_id><sink_block_id>blocks_probe_signal_amp</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier1_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier1_1</source_block_id><sink_block_id>msg_debug</sink_block_id><source_key>decoded_header</source_key><sink_key>store</sink_key></connection>
<connection><source_block_id>cdma_rx_hier1_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>cdma_rx_hier1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>cdma_rx_hier1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
