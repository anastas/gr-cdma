<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma_txrx</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>cdma_txrx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DataEsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est + 10*numpy.log10( 1.0-training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>DataEsN0dB_estimated</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>DataEsN0dB_est</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>DataEsN0dB_est</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>DataEsN0dBthreshold</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>10</value></param>
<param><key>grid_pos</key><value>8,0,1,1</value></param>
<param><key>label</key><value>DataEsN0dBthreshold</value></param>
<param><key>max</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>EsN0dB</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>EsN0dB</value></param>
<param><key>max</key><value>80</value></param>
<param><key>min</key><value>-20</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est</value></param>
<param><key>value</key><value>10*numpy.log10( cp.epsilon+ abs(Esest)/ (abs(N0est)+cp.epsilon) ) </value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>1e-2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N0</value></param>
<param><key>value</key><value>10**(-EsN0dB/10) * Es</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est</value></param>
<param><key>block_id</key><value>blocks_probe_signal_n0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RRCF_taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(2, samples_per_chip, 1.0, alpha_for_RRCF, RRCF_taps_len)</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>TrainingEsN0dB</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>TrainingEsN0dB_est</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>TrainingEsN0dB_est</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingEsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est + 10*numpy.log10( training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-10</value></param>
<param><key>grid_pos</key><value>7,0,1,1</value></param>
<param><key>label</key><value>acq_threshold_dB</value></param>
<param><key>max</key><value>20</value></param>
<param><key>min</key><value>-20</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_symbol</value></param>
<param><key>value</key><value>cp.chips_per_symbol</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>delay</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>max</key><value>100-1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>df</value></param>
<param><key>value</key><value>cp.df*samp_rate</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>df_Hz</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>df_Hz</value></param>
<param><key>max</key><value>cp.freqs[-1]*samp_rate</value></param>
<param><key>min</key><value>(cp.freqs[0]*samp_rate)-1e-6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>dft</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>df</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Deltaf (Hz)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>drift</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>label</key><value>drift  (ppm)</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>drift_v</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>drift*1e-6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>drift_v</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>fmaxt</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>cp.freqs[-1]*samp_rate</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>f_max (Hz)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est</value></param>
<param><key>block_id</key><value>blocks_probe_freq</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>freq_est_acq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq_acq_est</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value></value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>manual</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>6,0,1,1</value></param>
<param><key>label</key><value>Manual/Auto</value></param>
<param><key>labels</key><value>['Auto','Manual']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>n_filt</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>cp.n_filt</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>n_filt</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto</value></param>
<param><key>value</key><value>0 if DataEsN0dB_est&gt;DataEsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>onoff_manual</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
<param><key>label</key><value>Manual Acq/Tra</value></param>
<param><key>labels</key><value>['Tracking','Acquisition']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>button</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>map(int,numpy.random.randint(0,256,payload_bytes_per_frame))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_bytes_per_frame</value></param>
<param><key>value</key><value>cp.payload_bytes_per_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*chips_per_symbol</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>samples_per_chip</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>samples_per_chip</value></param>
<param><key>max</key><value>5</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>4</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cp.training_percent</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>'Acquisition' if onoff==1 else 'Tracking'</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Ack/Tra Status</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>RRCF_taps_len</value></param>
<param><key>label</key><value>length for RRCF taps</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha_for_RRCF</value></param>
<param><key>label</key><value>alpha for root-raise coise filter</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>bits_per_symbol</key><value>8</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>'SER'</value></param>
<param><key>win_size</key><value>10000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>Es**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_n0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>(symbol_rate*cp.bits_per_uncoded_symbol)/8</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>payload</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>payload</value></param>
</block>
<block>
<key>cdma_rx_hier</key>
<param><key>id</key><value>cdma_rx_hier_0</value></param>
<param><key>acq</key><value>onoff</value></param>
<param><key>acq_threshold_dB</key><value>acq_threshold_dB</value></param>
<param><key>alpha_for_RRCF</key><value>alpha_for_RRCF</value></param>
<param><key>RRCF_taps_len</key><value>RRCF_taps_len</value></param>
<param><key>samples_per_chip</key><value>samples_per_chip</value></param>
<param><key>zero_len</key><value>230</value></param>
</block>
<block>
<key>cdma_tx_hier</key>
<param><key>id</key><value>cdma_tx_hier_0</value></param>
<param><key>RRCF_gain</key><value>2</value></param>
<param><key>alpha_for_RRCF</key><value>alpha_for_RRCF</value></param>
<param><key>RRCF_taps_len</key><value>RRCF_taps_len</value></param>
<param><key>samples_per_chip</key><value>samples_per_chip</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0+drift*1e-6</value></param>
<param><key>freq_offset</key><value>df_Hz/samp_rate</value></param>
<param><key>noise_voltage</key><value>(chips_per_symbol*N0/2)**0.5</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>(delay)*(0,)+(1,)+(100-1-delay)*(0,)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy ; numpy.random.seed(666)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>import</key><value>from gnuradio.filter import firdes</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>We can not let the value for "samples_per_chip" to be controlled by slider, because we have to face the problem of changing the lenght of tags for xlating_FFT_filter during running. The filter will break down for changing buffer.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samples_per_chip</value></param>
<param><key>label</key><value>samples per chip</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>source</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>decoded_payload_bytes</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>decoded_payload_bytes</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>1</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>number_rate</key><value>1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>Units</value></param>
</block>
<connection><source_block_id>RX_0_2_1</source_block_id><sink_block_id>cdma_rx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_probe_freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>RX_training_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>cdma_tx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_amp</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_n0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>decoded_header</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_tx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_tx_hier_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
