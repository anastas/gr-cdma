<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma_txrx</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>cdma_txrx</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>AcqTraStatus</value></param>
<param><key>value</key><value>'Acquisition' if onoff==1 else 'Tracking'</value></param>
<param><key>gui_hint</key><value>status@0:0,0,1,1</value></param>
<param><key>label</key><value>Acq/Tra Status</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>Amp_est</value></param>
<param><key>value</key><value>"%3.2e" % Esest**0.5</value></param>
<param><key>gui_hint</key><value>status@0:5,0,1,1</value></param>
<param><key>label</key><value>Amp_estimate</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DataEsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est + 10*numpy.log10( 1.0-cp.training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>DataEsN0dB_estimated</value></param>
<param><key>value</key><value>"%3.2f" % DataEsN0dB_est</value></param>
<param><key>gui_hint</key><value>status@0:7,0,1,1</value></param>
<param><key>label</key><value>DataEsN0dB_est</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>DataEsN0dBthreshold</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>tabs@1:2,0,1,2</value></param>
<param><key>label</key><value>DataEsN0dBthreshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>EsN0dB</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>tabs@0:0,0,1,1</value></param>
<param><key>label</key><value>EsN0dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>80</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est</value></param>
<param><key>value</key><value>10*numpy.log10( cp.epsilon+ abs(Esest)/ (abs(N0est)+cp.epsilon) ) </value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1e-1</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>G</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>gui_hint</key><value>tabs@0:1,0,1,1</value></param>
<param><key>label</key><value>ChannelGain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>10.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Kippb</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Ki (ppb)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kippb</value></param>
<param><key>value</key><value>(Kpppm**2)/4 * 1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Kpppm</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tabs@1:3,0,1,2</value></param>
<param><key>label</key><value>Kp (ppm)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N0</value></param>
<param><key>value</key><value>10**(-EsN0dB/10) * Es</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est</value></param>
<param><key>block_id</key><value>blocks_probe_signal_n0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>TrainingEsN0dB</value></param>
<param><key>value</key><value>"%3.2f" % TrainingEsN0dB_est</value></param>
<param><key>gui_hint</key><value>status@0:6,0,1,1</value></param>
<param><key>label</key><value>TrainingEsN0dB_est</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingEsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est + 10*numpy.log10( cp.training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-7</value></param>
<param><key>gui_hint</key><value>tabs@1:1,0,1,2</value></param>
<param><key>label</key><value>acq_threshold_dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-30</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:3,0,1,1</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>df</value></param>
<param><key>value</key><value>cp.df*samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>df_Hz</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:2,0,1,1</value></param>
<param><key>label</key><value>df_Hz</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>3*cp.freqs[0]*samp_rate</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>3*cp.freqs[-1]*samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>dft</value></param>
<param><key>value</key><value>df</value></param>
<param><key>gui_hint</key><value>status@0:4,0,1,1</value></param>
<param><key>label</key><value>Deltaf (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>drift</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@0:4,0,1,1</value></param>
<param><key>label</key><value>drift (ppm)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>fmaxt</value></param>
<param><key>value</key><value>cp.freqs[-1]*samp_rate</value></param>
<param><key>gui_hint</key><value>status@0:3,0,1,1</value></param>
<param><key>label</key><value>f_max (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est</value></param>
<param><key>block_id</key><value>blocks_probe_freq</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>freq_est_acq</value></param>
<param><key>value</key><value>freq_acq_est</value></param>
<param><key>gui_hint</key><value>status@0:2,0,1,1</value></param>
<param><key>label</key><value>freq_est_acq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>manual</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@1:0,0,1,1</value></param>
<param><key>label</key><value>Auto/Manual</value></param>
<param><key>labels</key><value>['Auto', 'Manual']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>n_filt</value></param>
<param><key>value</key><value>cp.n_filt</value></param>
<param><key>gui_hint</key><value>status@0:1,0,1,1</value></param>
<param><key>label</key><value>n_filt</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto</value></param>
<param><key>value</key><value>0 if DataEsN0dB_est&gt;DataEsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>onoff_manual</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tabs@1:0,1,1,1</value></param>
<param><key>label</key><value>Manual Acq/Tra</value></param>
<param><key>labels</key><value>['Tracking', 'Acquisition']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*cp.chips_per_symbol*cp.samples_per_chip</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>G</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>Es**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_n0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>(symbol_rate*cp.bits_per_uncoded_symbol)/8</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0</value></param>
<param><key>samples_per_second</key><value>35e3</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((cp.payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>map(int,numpy.random.randint(0,256,cp.payload_bytes_per_frame))</value></param>
</block>
<block>
<key>cdma_pac_err_cal</key>
<param><key>id</key><value>cdma_pac_err_cal_0</value></param>
<param><key>cycsize</key><value>2**cp.bits_per_header_packet_index</value></param>
<param><key>pkt_num_tag</key><value>cdma_packet_num</value></param>
<param><key>winsize</key><value>999</value></param>
</block>
<block>
<key>cdma_rx_hier</key>
<param><key>id</key><value>cdma_rx_hier_0</value></param>
<param><key>Ki</key><value>Kippb*1e-9</value></param>
<param><key>Kp</key><value>Kpppm*1e-6</value></param>
<param><key>acq</key><value>onoff</value></param>
<param><key>acq_threshold_dB</key><value>acq_threshold_dB</value></param>
</block>
<block>
<key>cdma_tx_hier</key>
<param><key>id</key><value>cdma_tx_hier_0</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0+drift*1e-6</value></param>
<param><key>freq_offset</key><value>df_Hz/samp_rate</value></param>
<param><key>noise_voltage</key><value>(cp.chips_per_symbol*cp.samples_per_chip*N0/2)**0.5</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>(delay)*(0,)+(1,)+(100-1-delay)*(0,)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy ; numpy.random.seed(666)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>100</value></param>
<param><key>srate</key><value>symbol_rate/cp.symbols_per_frame</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>120</value></param>
<param><key>ymin</key><value>-120</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>status</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label0</key><value>Status</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label0</key><value>Channel</value></param>
<param><key>label1</key><value>Rx</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>source</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>decoded_payload_bytes</value></param>
</block>
<connection><source_block_id>RX_0_2_1</source_block_id><sink_block_id>cdma_rx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_probe_freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>RX_training_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>cdma_tx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0</source_block_id><sink_block_id>cdma_tx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>blocks_throttle_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_amp</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_n0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>decoded_header</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>cdma_pac_err_cal_0</sink_block_id><source_key>decoded_header</source_key><sink_key>errCal</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_tx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
