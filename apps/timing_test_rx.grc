<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>timing_test_rx</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts</value></param>
<param><key>value</key><value>tp.ts</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>tp.N</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freqs</value></param>
<param><key>value</key><value>[(2*k-n_filt+1)*df/2 for k in range(n_filt)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_filt</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>df</value></param>
<param><key>value</key><value>symbol_rate/N/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>peak</value></param>
<param><key>value</key><value>Q**2 * N**2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>var</value></param>
<param><key>value</key><value>Q**2 * N</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*Q</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Q</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>value</key><value>1e-12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>tp.symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse</value></param>
<param><key>value</key><value>filter.firdes.root_raised_cosine(Q,samp_rate,symbol_rate,0.35,5*Q)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total</value></param>
<param><key>value</key><value>numpy.convolve(pulse, numpy.kron(ts,(1,)+(Q-1)*(0,))[:(N-1)*Q+1:])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ts1</value></param>
<param><key>value</key><value>(0+0j,) if onoff==0 else total</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto</value></param>
<param><key>value</key><value>0 if EsN0dBest&gt;EsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dBthreshold</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import cdma.timing_parameters as tp</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/timing.fifo</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>from gnuradio import filter</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.20.3</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>1.2e9</value></param>
<param><key>gain0</key><value>25</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>acq_frequency</value></param>
<param><key>stream_id</key><value>acq frequency</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>manual</value></param>
<param><key>label</key><value>Manual/Auto</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['Auto','Manual']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>onoff_manual</value></param>
<param><key>label</key><value>Manual Acq/Tra</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['Tracking','Acquisition']</value></param>
<param><key>type</key><value>button</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>cdma_flag_gen</key>
<param><key>id</key><value>cdma_flag_gen_0</value></param>
<param><key>onoff</key><value>onoff</value></param>
<param><key>period</key><value>N*Q</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_1_0</value></param>
<param><key>stream_id</key><value>acq frequency</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>2*numpy.pi</value></param>
<param><key>amplitude</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>RX_training_0_3_0</value></param>
<param><key>stream_id</key><value>phase corrected training seq</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2</value></param>
<param><key>stream_id</key><value>RX_samples</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_0</value></param>
<param><key>stream_id</key><value>sync_flag</value></param>
</block>
<block>
<key>chopper_correlator</key>
<param><key>id</key><value>chopper_correlator_1</value></param>
<param><key>N</key><value>N</value></param>
<param><key>ts</key><value>ts</value></param>
<param><key>pulse</key><value>pulse</value></param>
<param><key>Q</key><value>Q</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>cdma_amp_var_est_hier</key>
<param><key>id</key><value>cdma_amp_var_est_hier_0</value></param>
<param><key>alpha</key><value>0.01</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>RX_0_2_2</value></param>
<param><key>stream_id</key><value>phase corrected training seq</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2.0</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1e-9</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_n0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_snr</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>block_id</key><value>blocks_probe_signal_n0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>acq_threshold</value></param>
<param><key>label</key><value>acq_threshold</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>EsN0dB Estimate</value></param>
<param><key>units</key><value>dB</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0.001</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>label</key><value>Ack/Tra Status</value></param>
<param><key>value</key><value>'Acquisition' if onoff==1 else 'Tracking'</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>freq_est(acq)</value></param>
<param><key>units</key><value>Hz</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>max_value</key><value>1e9</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0.001</value></param>
<param><key>show_gauge</key><value>False</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_timing_estimator_hier</key>
<param><key>id</key><value>freq_timing_estimator_hier_0</value></param>
<param><key>ts</key><value>ts1</value></param>
<param><key>factor</key><value>acq_threshold*(peak/var)</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freqs</key><value>freqs</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>EsN0dB_est</value></param>
<param><key>label</key><value>EsN0dB_est</value></param>
<param><key>value</key><value>EsN0dBest</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>EsN0dBest</value></param>
<param><key>value</key><value>20</value></param>
<param><key>block_id</key><value>blocks_probe_signal_snr</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>blocks_probe_freq</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>freq_est_acq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>freq_acq_est</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>symbol_rate</value></param>
<param><key>v_scale</key><value>0.25</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.25</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>RX_training_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_flag_gen_0</source_block_id><sink_block_id>RX_training_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1</source_block_id><sink_block_id>freq_timing_estimator_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_timing_estimator_hier_0</source_block_id><sink_block_id>cdma_flag_gen_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_timing_estimator_hier_0</source_block_id><sink_block_id>acq_frequency</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_timing_estimator_hier_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_timing_estimator_hier_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>RX_0_2</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_1_0</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_1</source_block_id><sink_block_id>chopper_correlator_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_0</source_block_id><sink_block_id>chopper_correlator_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>chopper_correlator_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_1</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_1</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_1</source_block_id><sink_block_id>blocks_null_sink_0_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chopper_correlator_1</source_block_id><sink_block_id>RX_training_0_3_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_probe_signal_n0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_amp_var_est_hier_0</source_block_id><sink_block_id>blocks_probe_signal_amp</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_amp_var_est_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_probe_signal_snr</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_amp_var_est_hier_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>RX_0_2_2</source_block_id><sink_block_id>cdma_amp_var_est_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_timing_estimator_hier_0</source_block_id><sink_block_id>blocks_probe_freq</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
